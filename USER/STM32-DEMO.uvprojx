# Keil uVision project STM32-DEMO.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\enc28j60;..\LWIP\ARCH;..\LWIP;..\enc28j60;..\app;..\LWIP\lwip-1.3.2\src\include;..\LWIP\lwip-1.3.2\src\include\ipv4;..\LWIP\lwip-1.3.2\src\include\netif;..\LWIP\lwip-1.3.2\src\include\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c usart1.c SysTick.c led.c
  group enc28j60
    ../enc28j60/: ENC28J60.C SPI.C
  group app
    ../app/: httpd.c netconfig.c cmd.c tcpd.c udpd.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group lwip-core
    ../LWIP/lwip-1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwip-core-ipv4
    ../LWIP/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-core-snmp
    ../LWIP/lwip-1.3.2/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwip-netif
    ../LWIP/lwip-1.3.2/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group readme
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
